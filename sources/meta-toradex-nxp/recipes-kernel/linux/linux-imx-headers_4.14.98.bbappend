SRCBRANCH = "toradex_4.14-2.3.x-imx"
LOCALVERSION = "-${SRCBRANCH}"
SRC_URI = "git://git.toradex.com/linux-toradex.git;protocol=git;branch=${SRCBRANCH}"
SRCREV = "b52b0a47036fc716ad95ec6385e2cb3bd4a11411"
