PV = "6.2.4.p4.8"
LOCALVERSION = "-${SRCBRANCH}"
SRCBRANCH = "imx_4.14.98_2.3.0"
SRCREV = "51ee01ba92534e2c57f0844a40c3223b041042f2"
