PV = "4.5.2"
LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"
SRC_URI[md5sum] = "9e0911bca999ad17a2c1d04379e8075a"
SRC_URI[sha256sum] = "e6d00ef760a7779846809b44dfbfabaee90678b229bc9a300c175088b7b2b537"
