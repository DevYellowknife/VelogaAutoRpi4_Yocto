PV = "4.5.2"
LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"
SRC_URI[md5sum] = "c6458ce98a0a6d5bd94df7917335d959"
SRC_URI[sha256sum] = "edcccf2cf29a7ae70d3d55c48a5985e583bf508baf29177b0474d68c7af2858e"
