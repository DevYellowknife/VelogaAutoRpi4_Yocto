FILESEXTRAPATHS_prepend := "${THISDIR}/gstreamer1.0-plugins-base:"
SRCBRANCH = "MM_04.05.02_1911_L4.14.98"
SRCREV = "5e8cc757e4fec72ee007ac12fab2d1333fce1dc9"
