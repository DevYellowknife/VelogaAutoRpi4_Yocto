RDEPENDS_${PN}_append_imxgpu = " ${PN}-etnaviv ${PN}-vivante"
