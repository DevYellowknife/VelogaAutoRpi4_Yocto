FILESEXTRAPATHS_prepend := "${THISDIR}/weston:"
SRCREV = "73a26456e43b6d4f72f0a995d437590065cafb15"
