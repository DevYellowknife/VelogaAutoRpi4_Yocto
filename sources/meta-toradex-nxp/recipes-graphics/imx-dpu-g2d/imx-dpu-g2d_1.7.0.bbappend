# update to 1.7.6
PV = "1.7.6"
LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"
SRC_URI[md5sum] = "a2672d00100bbcfc943ce865f0f7e2c9"
SRC_URI[sha256sum] = "100ec0b5cc3c14c46018c90cca5ab233c29efe0b2fe90edc752e3fd9e03f8342"
