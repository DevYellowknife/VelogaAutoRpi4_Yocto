PV = "5.4.39.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"
SRC_URI[md5sum] = "9f6136a1300d322078daaa9676054deb"
SRC_URI[sha256sum] = "b7bb67b00daf436fd91a2760c2db375a962e2c919045ce8bf81bd54b95d999c5"
