PV = "1.14.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"
SRC_URI = " \
    ${FSL_MIRROR}/${PN}-${PV}.bin;fsl-eula=true \
"
SRC_URI[md5sum] = "9e8751ff0e6dd1f8fe6e29d9a20de5b2"
SRC_URI[sha256sum] = "514043c5b8762ca0e2f58fa6be059f81521a93ccb7ce75ed4e41a96724d95cf5"
