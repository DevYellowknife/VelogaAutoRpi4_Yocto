RDEPENDS_${PN}_remove = " \
    boot2qt-appcontroller \
    boot2qt-launcher \
"